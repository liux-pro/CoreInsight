# Keil uVision project CoreInsight.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: CoreInsight +hex
  group Source Group 1
    ./: main.c
  group library
    ./library/: STC32G_GPIO.c STC32G_GPIO.h STC32G_ADC.c STC32G_ADC.h config.h
